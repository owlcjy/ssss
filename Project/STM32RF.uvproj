# Keil uVision project STM32RF.uvproj, settings and files
target STM32RF (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Source\STM32_FWLib\CMSIS;..\Source\STM32_FWLib\FWlib\inc;..\Source\Drivers;..\Source\Application\main;..\Source\EPD_W21
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Source/STM32_FWLib/CMSIS/startup/: startup_stm32f10x_hd.s
  group Application
    ../Source/Application/main/: main.c main.h stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group Drivers
    ../Source/Drivers/: oled.c usart1.c I2C.c SI7021.c Delay.c SPI.c gpio.c board.c matrixKey.c si446x.c
  group FWlib
    ../Source/STM32_FWLib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Source/STM32_FWLib/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c
  group EPDW21
    ../Source/EPD_W21/: Display_EPD_W21.c Display_EPD_W21_Aux.c
